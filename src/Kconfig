## src/Kconfig
```kconfig
config nf_test
    tristate "nf_test"
    default n
    help
        This is a netfilter example
```
